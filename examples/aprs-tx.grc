<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>msg</key><value>pmt.to_pmt((None, 'TEST'))</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
<param><key>host</key><value></value></param>
<param><key>port</key><value>52001</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
</block>
<block>
<key>bruninga_str_to_aprs</key>
<param><key>id</key><value>bruninga_str_to_aprs_0</value></param>
<param><key>src</key><value>KB3VOZ</value></param>
<param><key>dest</key><value>KB3VOZ</value></param>
<param><key>via</key><value>[]</value></param>
<param><key>preamble_len_ms</key><value>300</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>40</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[1]*40</value></param>
</block>
<block>
<key>blocks_vco_f</key>
<param><key>id</key><value>blocks_vco_f_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>2*math.pi</value></param>
<param><key>amplitude</key><value>0.1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>bruninga_str_to_aprs_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_vco_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>bruninga_str_to_aprs_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>bruninga_str_to_aprs_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_f_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
