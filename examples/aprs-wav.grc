options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: aprs_wav
    output_language: python
    run_options: run
  states: {}

blocks:
- name: attack
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: bpf_trans
  id: variable
  parameters:
    value: '200'
  states: {}
- name: bpf_width
  id: variable
  parameters:
    value: '800'
  states: {}
- name: decay
  id: variable
  parameters:
    value: '0.00022'
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '19200'
  states: {}
- name: window_field
  id: variable
  parameters:
    value: signal_tools.windows.cosine(window_len)
  states: {}
- name: window_len
  id: variable
  parameters:
    value: samp_rate/1200*2
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '44100'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1700+bpf_width
    low_cutoff_freq: 1700-bpf_width
    samp_rate: samp_rate
    type: fir_filter_fff
    width: bpf_trans
    win: window.WIN_RECTANGULAR
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '44100'
    type: float
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: examples/recordings/ISSpkt_full.wav
    repeat: 'False'
  states: {state: disabled}
- name: bruninga_direwolf_agc_0
  id: bruninga_direwolf_agc
  parameters:
    attack: attack
    decay: decay
  states: {}
- name: bruninga_direwolf_agc_0_0
  id: bruninga_direwolf_agc
  parameters:
    attack: attack
    decay: decay
  states: {}
- name: bruninga_hdlc_to_ax25_1
  id: bruninga_hdlc_to_ax25
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: gain_mu
    gain_omega: 0.25*gain_mu*gain_mu
    mu: '0.5'
    omega: 4*(1+0.0)
    omega_relative_limit: '0.05'
    type: float
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '15'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '1200'
    decim: '4'
    samp_rate: samp_rate
    taps: window_field
    type: fcf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '2200'
    decim: '4'
    samp_rate: samp_rate
    taps: window_field
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import scipy.signal as signal_tools
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from gnuradio import filter
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0
    label1: ''
    name: '"Bandpass Audio"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0
    label1: ''
    label2: ''
    name: '"Tone Detection"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate/4
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@1
    label1: ''
    label2: ''
    label3: ''
    name: '"AGC"'
    nconnections: '3'
    size: int(1024/4)
    srate: samp_rate/4
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@1
    label1: ''
    marker1: '0'
    name: '"Bits"'
    size: int(1024/4/4)
    srate: samp_rate/4/4
    style1: '0'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: samp_rate
    taps: ''
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Audio
    label1: Data
    num_tabs: '2'
  states: {}

connections:
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [band_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [band_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_and_const_xx_0, '0', digital_hdlc_deframer_bp_0, '0']
- [blocks_complex_to_mag_0, '0', bruninga_direwolf_agc_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', bruninga_direwolf_agc_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_not_xx_0, '0', blocks_and_const_xx_0, '0']
- [blocks_sub_xx_1, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [bruninga_direwolf_agc_0, '0', blocks_sub_xx_1, '0']
- [bruninga_direwolf_agc_0, '1', qtgui_time_sink_x_0_0_0, '1']
- [bruninga_direwolf_agc_0, '2', qtgui_time_sink_x_0_0_0, '2']
- [bruninga_direwolf_agc_0_0, '0', blocks_sub_xx_1, '1']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_not_xx_0, '0']
- [digital_hdlc_deframer_bp_0, out, bruninga_hdlc_to_ax25_1, in]
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [rational_resampler_xxx_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-82-gbc248667
