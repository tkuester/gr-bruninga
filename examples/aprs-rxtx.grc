options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: aprs_rxtx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: bruninga_ax25_fsk_mod_0
  id: bruninga_ax25_fsk_mod
  parameters:
    baud_rate: '1200'
    flag_count: '10'
    mark_freq: '2200'
    preamble_len_ms: '300'
    samp_rate: samp_rate
    space_freq: '1200'
  states: {}
- name: bruninga_fsk_demod_0
  id: bruninga_fsk_demod
  parameters:
    samp_rate: samp_rate
  states: {}
- name: bruninga_hdlc_to_ax25_1
  id: bruninga_hdlc_to_ax25
  parameters: {}
  states: {}
- name: bruninga_str_to_aprs_0
  id: bruninga_str_to_aprs
  parameters:
    dest: NOCALL
    src: NOCALL
    via: '[]'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '15'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}

connections:
- [audio_source_0, '0', bruninga_fsk_demod_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [bruninga_ax25_fsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [bruninga_fsk_demod_0, '0', digital_hdlc_deframer_bp_0, '0']
- [bruninga_str_to_aprs_0, out, bruninga_ax25_fsk_mod_0, in]
- [digital_hdlc_deframer_bp_0, out, bruninga_hdlc_to_ax25_1, in]
- [network_socket_pdu_0, pdus, bruninga_str_to_aprs_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-82-gbc248667
