options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: aprs_uhd
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 144.39e6-tuner_offset
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '79'
    value: '20'
  states: {state: disabled}
- name: rf_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '62500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 19.2e3
  states: {}
- name: tuner_offset
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '62500'
    max_dev: 5e3
    quad_rate: '62500'
    tau: '75e-6'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tkuester/rf_caps/aprs-f1.443800e+08-s6.250000e+04-t20140919151404.cfile
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*-tuner_offset/rf_samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '39062'
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/bjk/gnuradio/src/gr-bruninga/examples/recordings/SDRSharp_20150819_190253Z_145070kHz_IQ.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: bruninga_fsk_demod_0
  id: bruninga_fsk_demod
  parameters:
    samp_rate: samp_rate
  states: {}
- name: bruninga_hdlc_to_ax25_1
  id: bruninga_hdlc_to_ax25
  parameters: {}
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '15'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '8000'
    decim: '1'
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '39062'
    interp: '19200'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(62500)
    fbw: '1'
    interp: int(samp_rate)
    taps: '[1]'
    type: fff
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rf_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_file_source_0, '0', blocks_rotator_cc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_rotator_cc_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [bruninga_fsk_demod_0, '0', digital_hdlc_deframer_bp_0, '0']
- [digital_hdlc_deframer_bp_0, out, bruninga_hdlc_to_ax25_1, in]
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_rotator_cc_0, '0']
- [rational_resampler_xxx_1, '0', bruninga_fsk_demod_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_rotator_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-82-gbc248667
